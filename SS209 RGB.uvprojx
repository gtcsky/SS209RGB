# Keil uVision project SS209 RGB.uvprojx, settings and files
target SS209_RGB (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CX32L003F8 XMC
  pack: XMC.CX32L003_DFP.1.0.7
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SS209_RGB +hex
  AfterMake: fromelf --vhx --32x1 -o .\Objects\@L.bin .\Objects\@L.axf
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: .\USER\inc;.\Communication\inc;.\FWLB\inc;.\DEVICE
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group DEVICE
    ./DEVICE/: system_cx32l003.c startup_cx32l003.s
  group FWLB
    ./FWLB/src/: cx32l003_adc.c cx32l003_awk.c cx32l003_beeper.c cx32l003_clktrim.c cx32l003_crc.c cx32l003_debug.c cx32l003_exti.c cx32l003_flash.c cx32l003_gpio.c cx32l003_i2c.c cx32l003_it.c cx32l003_iwdt.c cx32l003_lptimer.c cx32l003_lpuart.c cx32l003_lvd.c cx32l003_owire.c cx32l003_pca.c cx32l003_rcc.c cx32l003_rtc.c cx32l003_spi.c cx32l003_syscon.c cx32l003_timer.c cx32l003_uart.c cx32l003_vc.c cx32l003_wwdt.c misc.c cx32l003_advtim.c
  group USER
    ./USER/src/: user_basetime.c user_exti.c user_internalFlash.c user_lptimer.c user_SysClock.c main.c user_key.c user_menu.c user_adc.c user_awk.c user_iwdt .c user_lcd.c user_ddl.c user_spi.c user_color.c communication.c user_i2c.c user_advtime.c user_lightEffect.c user_utils.c
  group DOC
    ./DOC/: readme.txt
software components: CMSIS:CORE 5.4.0
